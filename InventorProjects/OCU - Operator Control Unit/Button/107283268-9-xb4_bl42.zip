# Autodesk Inventor part: xb4_bl42_01
Saved by Autodesk Inventor 2015 (Build 190159000, 159)
## iProperties
Created: 2018-05
Part Number: xb4_bl42_01
Checked By: TraceParts S.A.
Material: Generic
Catalog Web Link: www.traceparts.com
Document SubType Name: Modeling
Designer: TraceParts
Density: 1 g/cm^3
Appearance: Default
Company: TraceParts S.A.
Author: TraceParts
## Design history (mm, degrees)
feature "xb4_bl42_01.ipt"
body "Solid1"
